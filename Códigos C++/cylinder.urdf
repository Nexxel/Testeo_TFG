Commit message: Added comments to the C++ code

File: Códigos C++/cylinder.urdf (robot description, URDF)
Before this commit: robot red_object, 1 links, 0 joints
Links:
- link my_object: geometry collision cylinder length=0.1 radius=0.012; visual cylinder length=0.1 radius=0.012
